# Keil uVision project FT.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: FT +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include;.\Include\driver;.\Include\types;.\Include\utils;.\Include\security
  group Source Group 1
    ./: STARTUP.A51 main.c Delay.c uart0.c typecon.c time.c eeprom.c i2c.c I2C.h
    ./Include/driver/: uart0.h
    ./Include/utils/: time.h eeprom.h typecon.h
